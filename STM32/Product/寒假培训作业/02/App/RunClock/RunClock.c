/*********************************************************************************************************
* 模块名称: RunClock.c
* 摘    要: 模拟时钟运行
* 当前版本: 1.0.0
* 作    者: SZLY(COPYRIGHT 2018 SZLY. All rights reserved.)
* 完成日期: 2018年01月01日 
* 内    容:
* 注    意: none                                                                  
**********************************************************************************************************
* 取代版本: 
* 作    者:
* 完成日期: 
* 修改内容:
* 修改文件: 
*********************************************************************************************************/

/*********************************************************************************************************
*                                              包含头文件
*********************************************************************************************************/
#include "RunClock.h"
#include <stdio.h>

/*********************************************************************************************************
*                                              宏定义
*********************************************************************************************************/

/*********************************************************************************************************
*                                              内部变量
*********************************************************************************************************/
static  i16 s_iHour;
static  i16 s_iMin ;
static  i16 s_iSec ;
static  int tmp[] = {0, 31, 59, 90, 120, 151, 181, 212, 243, 273, 304, 334, 365};

// static char weekday[] = {"日一二三四五六"};

static  u8  s_iClockPauseFlag = 0;  //TRUE-暂停，FALSE-正常运行
 
/*********************************************************************************************************
*                                              内部函数声明
*********************************************************************************************************/

/*********************************************************************************************************
*                                              内部函数实现
*********************************************************************************************************/
/*********************************************************************************************************
*                                              API函数实现
*********************************************************************************************************/
int CalMon(int day){
  u16 i = 0;
  for(i = 0; ; i++)
    if(day > tmp[i] && day <= tmp[i + 1]) return i;
}
/*********************************************************************************************************
* 函数名称: InitRunClock
* 函数功能: 初始化模块 
* 输入参数: void
* 输出参数: void
* 返 回 值: void
* 创建日期: 2018年01月01日
* 注    意:
*********************************************************************************************************/
void  InitRunClock(void)
{
  s_iHour = 0;
  s_iMin  = 0;
  s_iSec  = 0;
}

/*********************************************************************************************************
* 函数名称: RunClockPer2Ms
* 函数功能: 计数模块，每2ms调用一次 
* 输入参数: void
* 输出参数: void
* 返 回 值: void
* 创建日期: 2018年01月01日
* 注    意:
*********************************************************************************************************/
void  RunClockPer2Ms(void)
{
  static i16 s_iCnt500 = 0;

  if(499 <= s_iCnt500 && 0 == s_iClockPauseFlag)
  {
    if(59 <= s_iSec)
    {
      if(59 <= s_iMin)
      {
        if(23 <= s_iHour)
        {
          s_iHour = 0;
        }
        else
        {
          s_iHour++;
        }
        s_iMin = 0;
      }
      else
      {
        s_iMin++;
      }
      s_iSec = 0;
    }
    else
    {
      s_iSec++;
    }
    s_iCnt500 = 0;
  }
  else
  {
    s_iCnt500++;
  }
}

/*********************************************************************************************************
* 函数名称: PauseClock
* 函数功能: 实现时钟的启动和暂停 
* 输入参数: flag-1-Pause，0-Running
* 输出参数: void
* 返 回 值: void
* 创建日期: 2018年01月01日
* 注    意:
*********************************************************************************************************/      
void  PauseClock(u8 flag)
{
  s_iClockPauseFlag = flag;  
}

/*********************************************************************************************************
* 函数名称: GetTimeVal
* 函数功能: 获取当前的时间值 
* 输入参数: 时间值的类型
* 输出参数: void
* 返 回 值: 获取的时间值，小时、分钟或秒
* 创建日期: 2018年01月01日
* 注    意:
*********************************************************************************************************/
i16   GetTimeVal(u8 type)
{
  i16 timeVal;

  switch(type)
  {
  case TIME_VAL_HOUR:
    timeVal = s_iHour;
    break;
  case TIME_VAL_MIN:
    timeVal = s_iMin;
    break;
  case TIME_VAL_SEC:
    timeVal = s_iSec;
    break;
  default:
    break;
  } 
  
  return(timeVal);
}

/*********************************************************************************************************
* 函数名称: SetTimeVal
* 函数功能: 设置当前的时间值 
* 输入参数: type-时间值的类型，timeVal-要设置的时间值
* 输出参数: void
* 返 回 值: void
* 创建日期: 2018年01月01日
* 注    意:
*********************************************************************************************************/      
void  SetTimeVal(u8 type, i16 timeVal)
{
  switch(type)
  {
    case TIME_VAL_HOUR:
      s_iHour = timeVal;
      break;
    case TIME_VAL_MIN:
      s_iMin  = timeVal;
      break;
    case TIME_VAL_SEC:
      s_iSec  = timeVal;
      break;
    default:
      break;
  } 
}   

/*********************************************************************************************************
* 函数名称: DispTime
* 函数功能: 显示当前的时间
* 输入参数: hour, min, sec
* 输出参数: void
* 返 回 值: void
* 创建日期: 2018年01月01日
* 注    意:
*********************************************************************************************************/
void  DispTime(i16 hour, i16 min, i16 sec)    //显示当前的时间
{
  printf("Now is %02d:%02d:%02d\n", hour, min, sec);
}

void DispDay(u32 day){
  printf("2018年%d月%d日-星期", CalMon(day) + 1, (day - tmp[CalMon(day)]));
  switch (day % 7) {
    case 0:
      printf("七\n");
      break;
    case 1:
      printf("一\n");
      break;
    case 2:
      printf("二\n");
      break;
    case 3:
      printf("三\n");
      break;
    case 4:
      printf("四\n");
      break;
    case 5:
      printf("五\n");
      break;
    case 6:
      printf("六\n");
      break;
  }
}

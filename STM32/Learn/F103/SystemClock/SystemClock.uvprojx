# Keil uVision project SystemClock.uvprojx, settings and files
target SystemClock (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x00040000) IRAM(0x20000000,0x0000C000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SystemClock
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\dependence;.\src;.\dependence\build-in;.\dependence\build-in\STD;.\dependence\STM32F1xx_DFP;.\dependence\STM32F1xx_DFP\Startup;.\dependence\STM32F1xx_DFP\StdPeriphDrivers.Framework;.\dependence\STM32F1xx_DFP\StdPeriphDrivers.GPIO;.\dependence\STM32F1xx_DFP\StdPeriphDrivers.RCC;.\pack\Keil\STM32F1xx_DFP.2.3.0\Device\Include;.\pack\Keil\STM32F1xx_DFP.2.3.0\Device\StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group src
    ./src/: led.c led.h main.c Systick.c Systick.h
  group StdPeriphDrivers.RCC
    ./dependence/STM32F1xx_DFP/StdPeriphDrivers.RCC/: stm32f10x_rcc.c stm32f10x_rcc.h
  group StdPeriphDrivers.GPIO
    ./dependence/STM32F1xx_DFP/StdPeriphDrivers.GPIO/: stm32f10x_gpio.c stm32f10x_gpio.h
  group StdPeriphDrivers.Framework
    ./dependence/STM32F1xx_DFP/StdPeriphDrivers.Framework/: misc.c misc.h stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group Startup
    ./dependence/STM32F1xx_DFP/Startup/: core_cm3.h RTE_Device.h startup_stm32f10x_hd.s STM32F1xx_OPT.s system_stm32f10x.c
  group dependence
    ./dependence/: RTE_Components.h

# Keil uVision project USART.uvprojx, settings and files
target USART (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x00080000) IRAM(0x20000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: USART
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\dependence;.\src;.\dependence\build-in;.\dependence\build-in\STD;.\dependence\STM32F1xx_DFP;.\dependence\STM32F1xx_DFP\Startup;.\dependence\STM32F1xx_DFP\StdPeriphDrivers.Framework;.\dependence\STM32F1xx_DFP\StdPeriphDrivers.GPIO;.\dependence\STM32F1xx_DFP\StdPeriphDrivers.RCC;.\dependence\STM32F1xx_DFP\StdPeriphDrivers.USART;.\dependence\STM32F1xx_DFP\StdPeriphDrivers.ADC;.\dependence\STM32F1xx_DFP\StdPeriphDrivers.BKP;.\dependence\STM32F1xx_DFP\StdPeriphDrivers.CAN;.\dependence\STM32F1xx_DFP\StdPeriphDrivers.CEC;.\dependence\STM32F1xx_DFP\StdPeriphDrivers.CRC;.\dependence\STM32F1xx_DFP\StdPeriphDrivers.DAC;.\dependence\STM32F1xx_DFP\StdPeriphDrivers.DBGMCU;.\dependence\STM32F1xx_DFP\StdPeriphDrivers.DMA;.\dependence\STM32F1xx_DFP\StdPeriphDrivers.EXTI;.\dependence\STM32F1xx_DFP\StdPeriphDrivers.Flash;.\dependence\STM32F1xx_DFP\StdPeriphDrivers.FSMC;.\dependence\STM32F1xx_DFP\StdPeriphDrivers.I2C;.\dependence\STM32F1xx_DFP\StdPeriphDrivers.IWDG;.\dependence\STM32F1xx_DFP\StdPeriphDrivers.PWR;.\dependence\STM32F1xx_DFP\StdPeriphDrivers.RTC;.\dependence\STM32F1xx_DFP\StdPeriphDrivers.SDIO;.\dependence\STM32F1xx_DFP\StdPeriphDrivers.SPI;.\dependence\STM32F1xx_DFP\StdPeriphDrivers.TIM;.\dependence\STM32F1xx_DFP\StdPeriphDrivers.WWDG;.\pack\Keil\STM32F1xx_DFP.2.3.0\Device\StdPeriph_Driver\inc;.\pack\Keil\STM32F1xx_DFP.2.3.0\Device\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group src
    ./src/: bsp_usart.c bsp_usart.h core_cm3.h led.c led.h main.c
  group StdPeriphDrivers.USART
    ./dependence/STM32F1xx_DFP/StdPeriphDrivers.USART/: stm32f10x_usart.c stm32f10x_usart.h
  group StdPeriphDrivers.RCC
    ./dependence/STM32F1xx_DFP/StdPeriphDrivers.RCC/: stm32f10x_rcc.c stm32f10x_rcc.h
  group StdPeriphDrivers.GPIO
    ./dependence/STM32F1xx_DFP/StdPeriphDrivers.GPIO/: stm32f10x_gpio.c stm32f10x_gpio.h
  group StdPeriphDrivers.Framework
    ./dependence/STM32F1xx_DFP/StdPeriphDrivers.Framework/: misc.c misc.h stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group StdPeriphDrivers.EXTI
    ./dependence/STM32F1xx_DFP/StdPeriphDrivers.EXTI/: stm32f10x_exti.c stm32f10x_exti.h
  group Startup
    ./dependence/STM32F1xx_DFP/Startup/: RTE_Device.h startup_stm32f10x_hd.s system_stm32f10x.c
  group dependence
    ./dependence/: RTE_Components.h

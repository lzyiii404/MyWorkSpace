# Keil uVision project KeyInput.uvprojx, settings and files
target KeyInput (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  output: KeyInput
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\dependence;.\src\STARTUP;.\src;.\dependence\build-in;.\dependence\build-in\STD;.\src\CMSIS;.\src\FWLIB;.\src\USER;.\src\DOC;.\dependence\STM32F1xx_DFP;.\dependence\STM32F1xx_DFP\StdPeriphDrivers.Framework;.\dependence\STM32F1xx_DFP\GPIO;.\dependence\STM32F1xx_DFP\USART;.\dependence\STM32F1xx_DFP\StdPeriphDrivers.RCC;.\dependence\STM32F1xx_DFP\StdPeriphDrivers.GPIO;.\pack\Keil\STM32F1xx_DFP.2.3.0\Device\StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./src/USER/: Key.c Key.h led.c led.h main.c stm32f10x_it.h
  group STARTUP
    ./src/STARTUP/: startup_stm32f10x_hd.s
  group FWLIB
    ./src/FWLIB/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ./src/CMSIS/: core_cm3.h stm32f10x.h system_stm32f10x.h
  group dependence
    ./dependence/: RTE_Components.h

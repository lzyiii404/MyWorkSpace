# Keil uVision project DMA.uvprojx, settings and files
target DMA (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  output: DMA
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\dependence;.\src;.\dependence\build-in;.\dependence\build-in\STD;.\dependence\STM32F1xx_DFP;.\dependence\STM32F1xx_DFP\Startup;.\dependence\STM32F1xx_DFP\StdPeriphDrivers.Framework;.\dependence\STM32F1xx_DFP\StdPeriphDrivers.DMA;.\dependence\STM32F1xx_DFP\StdPeriphDrivers.EXTI;.\dependence\STM32F1xx_DFP\StdPeriphDrivers.GPIO;.\dependence\STM32F1xx_DFP\StdPeriphDrivers.RCC;.\dependence\STM32F1xx_DFP\StdPeriphDrivers.USART;.\pack\Keil\STM32F1xx_DFP.2.3.0\Device\Include;.\pack\Keil\STM32F1xx_DFP.2.3.0\Device\StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group src
    ./src/: bsp_usart.c bsp_usart.h dma.c dma.h led.c led.h main.c
  group StdPeriphDrivers.USART
    ./dependence/STM32F1xx_DFP/StdPeriphDrivers.USART/: stm32f10x_usart.c stm32f10x_usart.h
  group StdPeriphDrivers.RCC
    ./dependence/STM32F1xx_DFP/StdPeriphDrivers.RCC/: stm32f10x_rcc.c stm32f10x_rcc.h
  group StdPeriphDrivers.GPIO
    ./dependence/STM32F1xx_DFP/StdPeriphDrivers.GPIO/: stm32f10x_gpio.c stm32f10x_gpio.h
  group StdPeriphDrivers.Framework
    ./dependence/STM32F1xx_DFP/StdPeriphDrivers.Framework/: misc.c misc.h stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group StdPeriphDrivers.EXTI
    ./dependence/STM32F1xx_DFP/StdPeriphDrivers.EXTI/: stm32f10x_exti.c stm32f10x_exti.h
  group StdPeriphDrivers.DMA
    ./dependence/STM32F1xx_DFP/StdPeriphDrivers.DMA/: stm32f10x_dma.c stm32f10x_dma.h
  group Startup
    ./dependence/STM32F1xx_DFP/Startup/: core_cm3.h RTE_Device.h startup_stm32f10x_hd.s system_stm32f10x.c
  group dependence
    ./dependence/: RTE_Components.h
